# Keil uVision project 8x8LED.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 8x8LED
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: 8x8LED.c SPI_Init.h I2C_Init.h SysTick_Handler.h CONFIG.s CONVRT.s DELAY100.s MAINS.s REFRESH.s SEND_STRDATA.s SSI_WRITE.s
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
